# Keil uVision project DigoPot_Keil.uvprojx, settings and files
target DigoPot_Keil Configuration (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: DigoPot_Keil Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC
  c misc: --C99
  c include: ..\Inc; ..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_uart_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_spi.c stm32f0xx_hal_uart.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f091xc.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/User/TIM3
    ./: timer3_handler.h timer3_handler.c
  group Application/User/LCD
    ./: lcd_lib.c lcd_lib.h
